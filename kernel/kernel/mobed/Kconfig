## kernel/kernel/mobed/Kconfig
```kconfig
menu "MOBED - (EXPERIMENTAL)"

config MOBED
	bool "MOBED Experimental"
	default n

endmenu
```
